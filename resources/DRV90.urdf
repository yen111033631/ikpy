Commit message: urdf change; target_orientation = [0, 0, -1], orientation_mode=Z

File: resources/DRV90.urdf (robot description, URDF)
Before this commit: robot DRV90ASS.SLDASM, 7 links, 6 joints
Joints:
- joint Joint01: origin xyz=0 0 0 rpy=-1.5708 0 -3.1416 -> xyz=0 0 0 rpy=0 0 3.1416
